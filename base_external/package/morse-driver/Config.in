## base_external/package/morse-driver/Config.in
```kconfig
config BR2_PACKAGE_MORSE_DRIVER
	bool "morse-driver"
	help
	  Includes the Morse code driver.
```
